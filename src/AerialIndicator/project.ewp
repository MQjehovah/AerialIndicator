# IAR project project.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2132 MSP430F2132
  General.GStackSize2: 60
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2132.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: -Ointel-extended,(XDATA)=.eep; -Ointel-extended,(CODE)=.A90; -Ointel-extended,(CODE)=.hex
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 80
  ICC430.CCDefines: NDEBUG
  group (top)
    ./: Drivers.c main.c nRF905.c
